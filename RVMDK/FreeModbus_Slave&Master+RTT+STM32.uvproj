# Keil uVision project FreeModbus_Slave&Master+RTT+STM32.uvproj, settings and files
target STM32F103ZET6_FLASH (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BX_GeneralProgram
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libaries\CMSIS_MDK\CM3\CoreSupport;..\Libaries\CMSIS_MDK\CM3\DeviceSupport\ST\STM32F10x;..\Libaries\STM32F10x_StdPeriph_Driver\inc;..\Libaries\USB-FS-Device_Driver\inc;..\BSP\inc;..\APP\inc;..\RT-Thread-1.0.0\include;..\RT-Thread-1.0.0\libcpu\arm\stm32
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../APP/src/: app.c app_task.c stm32f4xx_it.c
    ../APP/inc/: delay_conf.h rtconfig.h
  group BSP
    ../BSP/src/: bsp.c usart.c gpio.c
    ../RT-Thread-1.2.2/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group CMSIS
    ../Libaries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libaries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group RT-Thread Kernel
    ../RT-Thread-1.2.2/src/: clock.c cpuusage.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group RT-Thread Drivers
    ../RT-Thread-1.2.2/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c wrokqueue.c
    ../RT-Thread-1.2.2/components/drivers/serial/: serial.c
    ../RT-Thread-1.2.2/components/drivers/misc/: pin.c
  group FreeModbusSlave
    ../FreeModbus/modbus/: mb.c
    ../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../FreeModbus/port/rtt/: port.c portevent.c portserial.c porttimer.c
    ../FreeModbus/port/: user_mb_app.c
  group FreeModbusMaster
    ../FreeModbus/modbus/: mb_m.c
    ../FreeModbus/modbus/rtu/: mbrtu_m.c
    ../FreeModbus/modbus/functions/: mbfuncholding_m.c mbfunccoils_m.c mbfuncinput_m.c mbfuncdisc_m.c
    ../FreeModbus/port/rtt/: portevent_m.c portserial_m.c porttimer_m.c
    ../FreeModbus/port/: user_mb_app_m.c
  group STM32_StdPeriph
    ../Libaries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
target STM32F407VG_FLASH (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: FreeModbus_Slaver&Master+RTT+STM32 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libaries\CMSIS_MDK\CM3\CoreSupport;..\Libaries\USB-FS-Device_Driver\inc;..\BSP\inc;..\APP\inc;..\RT-Thread-1.2.2\include;..\RT-Thread-1.2.2\components\drivers\include;..\RT-Thread-1.2.2\components\drivers\include\drivers;..\FreeModbus\modbus\include;..\FreeModbus\modbus\rtu;..\FreeModbus\port;..\Libaries\STM32F4xx_StdPeriph_Driver\inc;..\Libaries\CMSIS\Include;..\Libaries\CMSIS\ST\STM32F4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_* --keep __rt_init*
